<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
========
// SPDX-License-Identifier: (GPL-2.0+ OR MIT)
/*
 * Copyright (c) 2024 Focalcrest Co., Ltd.
 *
 */

>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
/dts-v1/;
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/leds/common.h>
#include <dt-bindings/display/rockchip_vop.h>
#include "rk3566.dtsi"
#include "rk3568-linux.dtsi"

/ {
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
	model = "RK3566 HA Green";
	compatible = "rockchip,rk3566-ha-green", "rockchip,rk3566";

	chosen: chosen {
		stdout-path = &uart2;
		u-boot,spl-boot-order = &sfc, &sdmmc0, &sdhci;
	};

	aliases: aliases {
		mmc0 = &sdhci;
		mmc1 = &sdmmc0;
		spi4 = &sfc;
	};

	fiq_debugger: fiq-debugger {
		compatible = "rockchip,fiq-debugger";
		rockchip,serial-id = <2>;
		rockchip,wake-irq = <0>;
		rockchip,irq-mode-enable = <1>;
		rockchip,baudrate = <1500000>;
		interrupts = <GIC_SPI 252 IRQ_TYPE_LEVEL_LOW>;
		pinctrl-names = "default";
		pinctrl-0 = <&uart2m0_xfer>;
		status = "okay";
	};

	dc_12v: dc-12v {
		compatible = "regulator-fixed";
		regulator-name = "dc_12v";
		regulator-always-on;
		regulator-boot-on;
		regulator-min-microvolt = <12000000>;
		regulator-max-microvolt = <12000000>;
========
	model = "Mixtile Edge 2";
	compatible = "focalcrest,mixtile-edge2", "rockchip,rk3568";

	aliases {
		ethernet0 = &gmac1;
		mmc0 = &sdhci;
		mmc1 = &sdmmc0;
		mmc2 = &sdmmc2;
	};

	chosen: chosen {
		stdout-path = "serial2:1500000n8";
	};

	hdmi-con {
		compatible = "hdmi-connector";
		type = "a";

		port {
			hdmi_con_in: endpoint {
				remote-endpoint = <&hdmi_out_con>;
			};
		};
	};

	leds {
		compatible = "gpio-leds";

		work_led: work {
			gpios = <&gpio0 RK_PC0 GPIO_ACTIVE_HIGH>;
			linux,default-trigger = "heartbeat";
		};
	};

	rk809-sound {
		compatible = "simple-audio-card";
		simple-audio-card,format = "i2s";
		simple-audio-card,name = "Analog RK809";
		simple-audio-card,mclk-fs = <256>;

		simple-audio-card,cpu {
			sound-dai = <&i2s1_8ch>;
		};

		simple-audio-card,codec {
			sound-dai = <&rk809>;
		};
	};

	sdio_pwrseq: sdio-pwrseq {
		compatible = "mmc-pwrseq-simple";
		clocks = <&rk809 1>;
		clock-names = "ext_clock";
		pinctrl-names = "default";
		pinctrl-0 = <&wifi_enable_h>;
		reset-gpios = <&gpio0 RK_PA5 GPIO_ACTIVE_LOW>;
		post-power-on-delay-ms = <200>;
	};

	vcc12v_dcin: vcc12v-dcin {
		compatible = "regulator-fixed";
		regulator-name = "vcc12v_dcin";
		regulator-always-on;
		regulator-boot-on;
	};

	vcc3v3_sys: vcc3v3-sys {
		compatible = "regulator-fixed";
		regulator-name = "vcc3v3_sys";
		regulator-always-on;
		regulator-boot-on;
		regulator-min-microvolt = <3300000>;
		regulator-max-microvolt = <3300000>;
		vin-supply = <&vcc12v_dcin>;
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
	};

	vcc5v0_sys: vcc5v0-sys {
		compatible = "regulator-fixed";
		regulator-name = "vcc5v0_sys";
		regulator-always-on;
		regulator-boot-on;
		regulator-min-microvolt = <5000000>;
		regulator-max-microvolt = <5000000>;
		vin-supply = <&vcc12v_dcin>;
	};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
	vcc5v0_usb_host: vcc5v0-usb-host {
========
	vcc5v0_usb_hub: vcc5v0-usb-hub {
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
		compatible = "regulator-fixed";
		regulator-name = "vcc5v0_usb_hub";
		regulator-always-on;
		regulator-boot-on;
		regulator-min-microvolt = <5000000>;
		regulator-max-microvolt = <5000000>;
		pinctrl-names = "default";
		pinctrl-0 = <&vcc5v0_usb_hub_en>;
		gpio = <&gpio3 RK_PB4 GPIO_ACTIVE_LOW>;
		vin-supply = <&vcc12v_dcin>;
	};

	vcc5v0_usb_host: vcc5v0-usb-host {
		compatible = "regulator-fixed";
		enable-active-high;
		gpio = <&gpio2 RK_PD0 GPIO_ACTIVE_HIGH>;
		pinctrl-names = "default";
		pinctrl-0 = <&vcc5v0_usb_host_en>;
		regulator-name = "vcc5v0_usb_host";
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
		enable-active-high;
		gpio = <&gpio0 RK_PA6 GPIO_ACTIVE_HIGH>;
========
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
		regulator-min-microvolt = <5000000>;
		regulator-max-microvolt = <5000000>;
	};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
	vcc3v3_sys: vcc3v3-sys {
		compatible = "regulator-fixed";
		regulator-name = "vcc3v3_sys";
		regulator-always-on;
		regulator-boot-on;
		regulator-min-microvolt = <3300000>;
		regulator-max-microvolt = <3300000>;
		vin-supply = <&dc_12v>;
	};

	leds: leds {
		compatible = "gpio-leds";

		led_power: led-power {
			label = "power";
			gpios = <&gpio0 RK_PB6 GPIO_ACTIVE_HIGH>;
			function = LED_FUNCTION_POWER;
			color = <LED_COLOR_ID_WHITE>;
			default-state = "keep";
			linux,default-trigger = "default-on";
			pinctrl-names = "default";
		};

		led_activity: led-activity {
			label = "activity";
			gpios = <&gpio0 RK_PB7 GPIO_ACTIVE_HIGH>;
			function = LED_FUNCTION_ACTIVITY;
			color = <LED_COLOR_ID_GREEN>;
			linux,default-trigger = "activity";
			pinctrl-names = "default";
		};

		led_user: led-user {
			label = "user";
			gpios = <&gpio0 RK_PC5 GPIO_ACTIVE_HIGH>;
			function = LED_FUNCTION_HEARTBEAT;
			color = <LED_COLOR_ID_YELLOW>;
			linux,default-trigger = "heartbeat";
			pinctrl-names = "default";
		};
	};

	hdmi_sound: hdmi-sound {
		compatible = "simple-audio-card";
		simple-audio-card,format = "i2s";
		simple-audio-card,mclk-fs = <128>;
		simple-audio-card,name = "rockchip,hdmi";
		status = "okay";

		simple-audio-card,cpu {
				sound-dai = <&i2s0_8ch>;
		};
		simple-audio-card,codec {
				sound-dai = <&hdmi>;
		};
	};

	test_power: test-power {
			status = "okay";
	};
};

&mdio1 {
	rgmii_phy1: ethernet-phy@0 {
		compatible = "ethernet-phy-ieee802.3-c22";
		reg = <0x0>;
	};
};

&gmac1 {
	assigned-clocks = <&cru SCLK_GMAC1_RX_TX>, <&cru SCLK_GMAC1>;
	assigned-clock-parents = <&cru SCLK_GMAC1_RGMII_SPEED>;
	assigned-clock-rates = <0>, <125000000>;
	clock_in_out = "output";

	snps,reset-gpio = <&gpio4 RK_PC2 GPIO_ACTIVE_LOW>;
	snps,reset-active-low;
	snps,reset-delays-us = <0 20000 100000>;

	phy-handle = <&rgmii_phy1>;
	phy-mode = "rgmii";

	pinctrl-names = "default";
	pinctrl-0 = <&gmac1m0_miim
			 &gmac1m0_tx_bus2
			 &gmac1m0_rx_bus2
			 &gmac1m0_rgmii_clk
			 &gmac1m0_rgmii_bus>;

	tx_delay = <0x47>;
	rx_delay = <0x27>;

	status = "okay";
};

&bus_npu {
	bus-supply = <&vdd_logic>;
	pvtm-supply = <&vdd_cpu>;
========
	vcc3v3_pcie: vcc3v3-pcie {
		compatible = "regulator-fixed";
		regulator-name = "vcc3v3_pcie";
		regulator-min-microvolt = <3300000>;
		regulator-max-microvolt = <3300000>;
		enable-active-high;
		regulator-always-on;
		regulator-boot-on;
		pinctrl-names = "default";
		pinctrl-0 = <&vcc3v3_pcie_en_pin>;
		gpio = <&gpio3 RK_PB3 GPIO_ACTIVE_HIGH>;
		vin-supply = <&vcc12v_dcin>;
	};

	vcc3v3_m2: vcc3v3-m2 {
		compatible = "regulator-fixed";
		regulator-name = "vcc3v3_m2";
		regulator-min-microvolt = <3300000>;
		regulator-max-microvolt = <3300000>;
		enable-active-high;
		regulator-always-on;
		regulator-boot-on;
		gpio = <&gpio0 RK_PD4 GPIO_ACTIVE_HIGH>;
	};

	vcc1v8_m2: vcc1v8-m2 {
		compatible = "regulator-fixed";
		regulator-name = "vcc1v8_m2";
		regulator-min-microvolt = <1800000>;
		regulator-max-microvolt = <1800000>;
		regulator-always-on;
		regulator-boot-on;
		pinctrl-names = "default";
		pinctrl-0 = <&vcc1v8_m2_pin>;
		gpio = <&gpio1 RK_PD2 GPIO_ACTIVE_LOW>;
	};

	vcc3v3_minipcie: vcc3v3-minipcie {
		compatible = "regulator-fixed";
		regulator-name = "vcc3v3_minipcie";
		regulator-always-on;
		regulator-boot-on;
		enable-active-high;
		regulator-min-microvolt = <3300000>;
		regulator-max-microvolt = <3300000>;
		gpio = <&gpio0 RK_PC5 GPIO_ACTIVE_HIGH>;
		vin-supply = <&vcc5v0_sys>;
	};
};

&combphy0 {
	status = "okay";
};

&combphy1 {
	status = "okay";
};

&combphy2 {
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
	status = "okay";
};

&cpu0 {
	cpu-supply = <&vdd_cpu>;
};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
&dfi {
	status = "okay";
};

&dmc {
	center-supply = <&vdd_logic>;
	status = "okay";
========
&cpu1 {
	cpu-supply = <&vdd_cpu>;
};

&cpu2 {
	cpu-supply = <&vdd_cpu>;
};

&cpu3 {
	cpu-supply = <&vdd_cpu>;
};

&gmac1 {
	assigned-clocks = <&cru SCLK_GMAC1_RX_TX>, <&cru SCLK_GMAC1>;
	assigned-clock-parents = <&cru SCLK_GMAC1_RGMII_SPEED>,<&cru CLK_MAC1_2TOP>;
	assigned-clock-rates = <0>, <125000000>;
	clock_in_out = "output";
	snps,reset-gpio = <&gpio2 RK_PD1 GPIO_ACTIVE_LOW>;
	snps,reset-active-low;
	/* Reset time is 20ms, 100ms for rtl8211f */
	snps,reset-delays-us = <0 20000 100000>;
	phy-handle = <&rgmii_phy1>;
	phy-mode = "rgmii-id";
	pinctrl-names = "default";
	pinctrl-0 = <&gmac1m1_miim
		     &gmac1m1_tx_bus2
		     &gmac1m1_rx_bus2
		     &gmac1m1_rgmii_clk
		     &gmac1m1_rgmii_bus>;
	status = "okay";
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
};

&gpu {
	clock-names = "gpu", "bus";
	interrupt-names = "gpu", "mmu", "job";
	mali-supply = <&vdd_gpu>;
	status = "okay";
};

&display_subsystem {
	status = "okay";
};

&hdmi {
	status = "okay";
};

&hdmi_in_vp0 {
	status = "okay";
};

&hdmi_sound {
	status = "okay";
};

&route_hdmi {
	connect = <&vp0_out_hdmi>;
	status = "okay";
};

&i2c0 {
	status = "okay";

	vdd_cpu: rk8601@41 {
		compatible = "rockchip,rk8601";
		reg = <0x41>;
		vin-supply = <&vcc5v0_sys>;
		regulator-compatible = "rk860x-reg";
		regulator-name = "vdd_cpu";
		regulator-min-microvolt = <712500>;
		regulator-max-microvolt = <1500000>;
		regulator-ramp-delay = <2300>;
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
		rockchip,suspend-voltage-selector = <1>;
		regulator-boot-on;
		regulator-always-on;
========
		vin-supply = <&vcc5v0_sys>;

>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
		regulator-state-mem {
			regulator-off-in-suspend;
		};
	};

	rk809: pmic@20 {
		compatible = "rockchip,rk809";
		reg = <0x20>;
		interrupt-parent = <&gpio0>;
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
		interrupts = <3 IRQ_TYPE_LEVEL_LOW>;

========
		interrupts = <RK_PA3 IRQ_TYPE_LEVEL_LOW>;
		assigned-clocks = <&cru I2S1_MCLKOUT_TX>;
		assigned-clock-parents = <&cru CLK_I2S1_8CH_TX>;
		#clock-cells = <1>;
		clock-names = "mclk";
		clocks = <&cru I2S1_MCLKOUT_TX>;
		pinctrl-names = "default";
		pinctrl-0 = <&pmic_int>, <&i2s1m0_mclk>;
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
		rockchip,system-power-controller;
		wakeup-source;
		#clock-cells = <1>;
		clock-output-names = "rk808-clkout1", "rk808-clkout2";
		pmic-reset-func = <0>;
		not-save-power-en = <1>;

		vcc1-supply = <&vcc3v3_sys>;
		vcc2-supply = <&vcc3v3_sys>;
		vcc3-supply = <&vcc3v3_sys>;
		vcc4-supply = <&vcc3v3_sys>;
		vcc5-supply = <&vcc3v3_sys>;
		vcc6-supply = <&vcc3v3_sys>;
		vcc7-supply = <&vcc3v3_sys>;
		vcc8-supply = <&vcc3v3_sys>;
		vcc9-supply = <&vcc3v3_sys>;

		pwrkey {
			status = "okay";
		};

		regulators {
			vdd_logic: DCDC_REG1 {
				regulator-name = "vdd_logic";
				regulator-always-on;
				regulator-boot-on;
				regulator-init-microvolt = <900000>;
				regulator-initial-mode = <0x2>;
				regulator-min-microvolt = <500000>;
				regulator-max-microvolt = <1350000>;
				regulator-ramp-delay = <6001>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vdd_gpu: DCDC_REG2 {
				regulator-name = "vdd_gpu";
				regulator-always-on;
				regulator-init-microvolt = <900000>;
				regulator-initial-mode = <0x2>;
				regulator-min-microvolt = <500000>;
				regulator-max-microvolt = <1350000>;
				regulator-ramp-delay = <6001>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vcc_ddr: DCDC_REG3 {
				regulator-name = "vcc_ddr";
				regulator-always-on;
				regulator-boot-on;
				regulator-initial-mode = <0x2>;

				regulator-state-mem {
					regulator-on-in-suspend;
				};
			};

			vdd_npu: DCDC_REG4 {
				regulator-name = "vdd_npu";
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
				regulator-always-on;
				regulator-boot-on;
========
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
				regulator-init-microvolt = <900000>;
				regulator-initial-mode = <0x2>;
				regulator-min-microvolt = <500000>;
				regulator-max-microvolt = <1350000>;
				regulator-ramp-delay = <6001>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vcc_1v8: DCDC_REG5 {
				regulator-name = "vcc_1v8";
				regulator-always-on;
				regulator-boot-on;
				regulator-min-microvolt = <1800000>;
				regulator-max-microvolt = <1800000>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vdda0v9_image: LDO_REG1 {
				regulator-name = "vdda0v9_image";
				regulator-min-microvolt = <900000>;
				regulator-max-microvolt = <900000>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vdda_0v9: LDO_REG2 {
				regulator-name = "vdda_0v9";
				regulator-always-on;
				regulator-boot-on;
				regulator-min-microvolt = <900000>;
				regulator-max-microvolt = <900000>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vdda0v9_pmu: LDO_REG3 {
				regulator-name = "vdda0v9_pmu";
				regulator-always-on;
				regulator-boot-on;
				regulator-min-microvolt = <900000>;
				regulator-max-microvolt = <900000>;

				regulator-state-mem {
					regulator-on-in-suspend;
					regulator-suspend-microvolt = <900000>;
				};
			};

			vccio_acodec: LDO_REG4 {
				regulator-name = "vccio_acodec";
				regulator-always-on;
				regulator-min-microvolt = <3300000>;
				regulator-max-microvolt = <3300000>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vccio_sd: LDO_REG5 {
				regulator-name = "vccio_sd";
				regulator-min-microvolt = <1800000>;
				regulator-max-microvolt = <3300000>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vcc3v3_pmu: LDO_REG6 {
				regulator-name = "vcc3v3_pmu";
				regulator-always-on;
				regulator-boot-on;
				regulator-min-microvolt = <3300000>;
				regulator-max-microvolt = <3300000>;

				regulator-state-mem {
					regulator-on-in-suspend;
					regulator-suspend-microvolt = <3300000>;
				};
			};

			vcca_1v8: LDO_REG7 {
				regulator-name = "vcca_1v8";
				regulator-always-on;
				regulator-boot-on;
				regulator-min-microvolt = <1800000>;
				regulator-max-microvolt = <1800000>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vcca1v8_pmu: LDO_REG8 {
				regulator-name = "vcca1v8_pmu";
				regulator-always-on;
				regulator-boot-on;
				regulator-min-microvolt = <1800000>;
				regulator-max-microvolt = <1800000>;

				regulator-state-mem {
					regulator-on-in-suspend;
					regulator-suspend-microvolt = <1800000>;
				};
			};

			vcca1v8_image: LDO_REG9 {
				regulator-name = "vcca1v8_image";
				regulator-min-microvolt = <1800000>;
				regulator-max-microvolt = <1800000>;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vcc_3v3: SWITCH_REG1 {
				regulator-name = "vcc_3v3";
				regulator-always-on;
				regulator-boot-on;

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};

			vcc3v3_sd: SWITCH_REG2 {
				regulator-name = "vcc3v3_sd";

				regulator-state-mem {
					regulator-off-in-suspend;
				};
			};
		};

		codec {
			mic-in-differential;
		};
	};
};


&i2c4 {
	pinctrl-names = "default";
	pinctrl-0 = <&i2c4m1_xfer>;
	status = "disabled";
};

&i2c3 {
	pinctrl-names = "default";
	pinctrl-0 = <&i2c3m0_xfer>;
	status = "okay";

	hym8563: rtc@51 {
		compatible = "haoyu,hym8563";
		reg = <0x51>;
		interrupt-parent = <&gpio0>;
		interrupts = <RK_PD3 IRQ_TYPE_LEVEL_LOW>;
		#clock-cells = <0>;
		clock-output-names = "rtcic_32kout";
		pinctrl-names = "default";
		pinctrl-0 = <&hym8563_int>;
		wakeup-source;
	};
};

&i2c1 {
	clock-frequency = <400000>;
	status = "okay";

	rtc: rtc@51 {
		compatible = "nxp,pcf8563";
		reg = <0x51>;
		#clock-cells = <0>;
	};
};

&i2s0_8ch {
	status = "okay";
};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
========
&i2s1_8ch {
	pinctrl-names = "default";
	pinctrl-0 = <&i2s1m0_sclktx &i2s1m0_lrcktx &i2s1m0_sdi0 &i2s1m0_sdo0>;
	rockchip,trcm-sync-tx-only;
	status = "okay";
};

&mdio1 {
	rgmii_phy1: ethernet-phy@0 {
		compatible = "ethernet-phy-ieee802.3-c22";
		reg = <0x0>;
	};
};

&pcie30phy {
	status = "okay";
};

&pcie3x2 {
	pinctrl-names = "default";
	pinctrl-0 = <&pcie30x2m1_pins>;
	reset-gpios = <&gpio3 RK_PC1 GPIO_ACTIVE_HIGH>;
	vpcie3v3-supply = <&vcc3v3_pcie>;
	status = "okay";
};

&pinctrl {
	ethernet {
		eth_phy_rst: eth_phy_rst {
			rockchip,pins = <3 RK_PB0 RK_FUNC_GPIO &pcfg_pull_none>;
		};
	};

	hym8563 {
		hym8563_int: hym8563-int {
			rockchip,pins = <0 RK_PD3 RK_FUNC_GPIO &pcfg_pull_up>;
		};
	};

	bt {
		bt_enable: bt-enable {
			rockchip,pins = <3 RK_PA0 RK_FUNC_GPIO &pcfg_pull_none>;
		};

		bt_host_wake: bt-host-wake {
			rockchip,pins = <3 RK_PA1 RK_FUNC_GPIO &pcfg_pull_down>;
		};

		bt_wake: bt-wake {
			rockchip,pins = <3 RK_PA2 RK_FUNC_GPIO &pcfg_pull_none>;
		};
	};

	pcie {
		vcc3v3_pcie_en_pin: vcc3v3-pcie-en-pin {
			rockchip,pins = <0 RK_PD4 RK_FUNC_GPIO &pcfg_pull_none>;
		};
	};

	sdio-pwrseq {
		wifi_enable_h: wifi-enable-h {
			rockchip,pins = <0 RK_PA5 RK_FUNC_GPIO &pcfg_pull_none>;
		};
	};

	pmic {
		pmic_int: pmic_int {
			rockchip,pins =
				<0 RK_PA3 RK_FUNC_GPIO &pcfg_pull_up>;
		};
	};

	usb {
		vcc5v0_usb_host_en: vcc5v0_usb_host_en {
			rockchip,pins = <2 RK_PD0 RK_FUNC_GPIO &pcfg_pull_none>;
		};
		vcc5v0_usb_hub_en: vcc5v0_usb_hub_en {
			rockchip,pins = <0 RK_PD5 RK_FUNC_GPIO &pcfg_pull_none>;
		};
	};

	vcc1v8-m2-pin {
		vcc1v8_m2_pin: vcc1v8-m2-pin {
			rockchip,pins = <1 RK_PD2 RK_FUNC_GPIO &pcfg_pull_none>;
		};
	};
};

>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
&pmu_io_domains {
	pmuio1-supply = <&vcc3v3_pmu>;
	pmuio2-supply = <&vcc3v3_pmu>;
	vccio1-supply = <&vccio_acodec>;
	vccio2-supply = <&vcc_1v8>;
	vccio3-supply = <&vccio_sd>;
	vccio4-supply = <&vcc_1v8>;
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
	vccio5-supply = <&vcc_1v8>;
========
	vccio5-supply = <&vcc_3v3>;
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
	vccio6-supply = <&vcc_1v8>;
	vccio7-supply = <&vcc_3v3>;
	status = "okay";
};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
========
&saradc {
	vref-supply = <&vcca_1v8>;
	status = "okay";
};

>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
&sdhci {
	pinctrl-names = "default";
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
	pinctrl-0 = <&emmc_clk &emmc_cmd &emmc_bus8>;
	bus-width = <8>;
	mmc-hs200-1_8v;
	no-sdio;
	no-sd;
	non-removable;
	max-frequency = <200000000>;
========
	pinctrl-0 = <&emmc_bus8 &emmc_clk &emmc_cmd &emmc_datastrobe>;
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
	vmmc-supply = <&vcc_3v3>;
	vqmmc-supply = <&vcc_1v8>;
	status = "okay";
};

&sdmmc0 {
	pinctrl-names = "default";
	pinctrl-0 = <&sdmmc0_bus4 &sdmmc0_clk &sdmmc0_cmd &sdmmc0_det>;
	bus-width = <4>;
	cap-sd-highspeed;
	cd-gpios = <&gpio0 RK_PA4 GPIO_ACTIVE_LOW>;
	disable-wp;
	sd-uhs-sdr104;
	vmmc-supply = <&vcc3v3_sd>;
	vqmmc-supply = <&vccio_sd>;
	status = "okay";
};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
&sfc {
	pinctrl-0 = <&fspi_pins>;
========
&sdmmc2 {
	supports-sdio;
	bus-width = <4>;
	disable-wp;
	cap-sd-highspeed;
	cap-sdio-irq;
	keep-power-in-suspend;
	mmc-pwrseq = <&sdio_pwrseq>;
	non-removable;
	sd-uhs-sdr50;
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
	pinctrl-names = "default";
	pinctrl-0 = <&sdmmc2m0_bus4 &sdmmc2m0_cmd &sdmmc2m0_clk>;
	status = "okay";
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts

	flash@0 {
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <24000000>;
		spi-rx-bus-width = <1>;
		spi-tx-bus-width = <1>;
	};
========
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
};

&tsadc {
	rockchip,hw-tshut-mode = <1>;
	rockchip,hw-tshut-polarity = <0>;
	status = "okay";
};

&saradc {
	vref-supply = <&vcca_1v8>;
	status = "okay";
};

&uart2 {
	status = "disabled";
};

&rng {
	status = "okay";
};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
&crypto {
========
&uart4 {
	status = "okay";
	pinctrl-names = "default";
	pinctrl-0 = <&uart4m1_xfer>;
};

&uart8 {
	status = "okay";
	pinctrl-names = "default";
	pinctrl-0 = <&uart8m0_xfer &uart8m0_ctsn &uart8m0_rtsn>;

	bluetooth {
		compatible = "brcm,bcm43438-bt";
		clocks = <&rk809 1>;
		clock-names = "lpo";
		device-wakeup-gpios = <&gpio3 RK_PA2 GPIO_ACTIVE_HIGH>;
		host-wakeup-gpios = <&gpio3 RK_PA1 GPIO_ACTIVE_HIGH>;
		shutdown-gpios = <&gpio3 RK_PA0 GPIO_ACTIVE_HIGH>;
		pinctrl-names = "default";
		pinctrl-0 = <&bt_host_wake &bt_wake &bt_enable>;
		vbat-supply = <&vcc3v3_sys>;
		vddio-supply = <&vcc_1v8>;
		/* vddio comes from regulator on module, use IO bank voltage instead */
	};
};

&usb_host0_ehci {
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
	status = "okay";
};

&iep {
	status = "okay";
};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
&iep_mmu {
========
&usb_host0_xhci {
	extcon = <&usb2phy0>;
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
	status = "okay";
};

&jpegd {
	status = "okay";
};

&jpegd_mmu {
	status = "okay";
};

&mpp_srv {
	status = "okay";
};

&rk_rga {
	status = "okay";
};

&rkvdec {
	status = "okay";
};

<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts
&rkvdec_mmu {
========
&usb2phy0_otg {
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
	status = "okay";
};

&rkvenc {
	venc-supply = <&vdd_logic>;
	status = "okay";
};

&rkvenc_mmu {
	status = "okay";
};

&rknpu {
	rknpu-supply = <&vdd_npu>;
	status = "okay";
};

&rknpu_mmu {
	status = "okay";
};

&vdpu {
	status = "okay";
};

&vdpu_mmu {
	status = "okay";
};

&vepu {
	status = "okay";
};

&vepu_mmu {
	status = "okay";
};

&vop {
	assigned-clocks = <&cru DCLK_VOP0>, <&cru DCLK_VOP1>;
	assigned-clock-parents = <&pmucru PLL_HPLL>, <&cru PLL_VPLL>;
	status = "okay";
};

&vop_mmu {
	status = "okay";
};

&vp0 {
	rockchip,plane-mask = <(1 << ROCKCHIP_VOP2_CLUSTER0 | 1 << ROCKCHIP_VOP2_ESMART0)>;
	rockchip,primary-plane = <ROCKCHIP_VOP2_ESMART0>;
};
<<<<<<<< HEAD:patch/kernel/rk35xx-vendor-6.1/dt/rk3566-ha-green.dts

&u2phy0_host {
	phy-supply = <&vcc5v0_usb_host>;
	status = "okay";
};

&u2phy0_otg {
	phy-supply = <&vcc5v0_usb_host>;
	status = "okay";
};

&u2phy1_host {
	phy-supply = <&vcc5v0_usb_host>;
	status = "okay";
};

&u2phy1_otg {
	phy-supply = <&vcc5v0_usb_host>;
	status = "okay";
};

&usb2phy0 {
	status = "okay";
};

&usb2phy1 {
	status = "okay";
};

&usb_host0_ehci {
	status = "okay";
};

&usb_host0_ohci {
	status = "okay";
};

&usb_host1_ehci {
	status = "okay";
};

&usb_host1_ohci {
	status = "okay";
};
========
>>>>>>>> 91978d7e6a913507d6ce36bc324eb698b42d20c1:patch/kernel/archive/rockchip64-6.6/dt/rk3568-mixtile-edge2.dts
